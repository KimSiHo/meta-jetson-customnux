inherit externalsrc

EXTERNALSRC = "/home/sihokim/projects/nvidia-oot"
EXTERNALSRC_BUILD = "/home/sihokim/projects/nvidia-oot"
