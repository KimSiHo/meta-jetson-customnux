inherit core-image

IMAGE_ROOTFS_SIZE = "20480"
IMAGE_ROOTFS_EXTRA_SPACE = "20480"
IMAGE_ROOTFS_ALIGNMENT = "1024"
