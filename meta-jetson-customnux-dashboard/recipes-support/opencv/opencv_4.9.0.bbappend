PACKAGECONFIG += "python3 gstreamer"
