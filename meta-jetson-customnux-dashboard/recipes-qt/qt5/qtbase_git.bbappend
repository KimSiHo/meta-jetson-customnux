PACKAGECONFIG_SYSTEM += "xkbcommon"
PACKAGECONFIG_FONTS += "fontconfig"
