PACKAGECONFIG:append:tegra = " libv4l2"
